## src/modules/cfg_logger/Kconfig
```kconfig
menuconfig MODULES_CFG_LOGGER
	bool "cfg_logger"
	default n
	---help---
		Enable support for cfg_logger
```
